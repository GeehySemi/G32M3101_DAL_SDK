# IAR project IAP_Bootloader.ewp, settings and files
configuration G32M3101 (ARM, debug)
  General.OGChipSelectEditMenu: G32M3101x8 Geehy G32M3101x8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_FULL_DDL_DRIVER; G32M3101xx; BOARD_G32M3101_EVAL
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\Libraries\G32M3101_DAL_Driver\Include; ..\..\..\..\..\..\Libraries\CMSIS\Include; ..\..\..\..\..\..\Libraries\Device\Geehy\G32M3101\Include; ..\..\Include; ..\..\Config\Include; ..\..\..\..\..\..\Boards\Board_G32M3101_Eval\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Template.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: IAP_Bootloader.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../../Source/: g32m3101_int.c iap_common.c iap_flash.c iap_menu.c iap_ymodem.c main.c
  group Board
    ../../../../../../Boards/Board_G32M3101_Eval/Source/: board_g32m3101_eval_ddl.c
  group CMSIS
    ./: startup_g32m3101xx.s
    ../../Source/: system_g32m3101.c
  group Config
    ../../Config/Source/: g32m3101_device_cfg.c g32m3101_usart_cfg.c
  group Document
    ../../: readme.txt
  group G32M3101_DDL_Driver
    ../../../../../../Libraries/G32M3101_DAL_Driver/Source/: g32m3101_ddl_adc.c g32m3101_ddl_atmr.c g32m3101_ddl_btmr.c g32m3101_ddl_comp.c g32m3101_ddl_crc.c g32m3101_ddl_div.c g32m3101_ddl_dma.c g32m3101_ddl_eint.c g32m3101_ddl_flash.c g32m3101_ddl_gpio.c g32m3101_ddl_gtmr.c g32m3101_ddl_lptmr.c g32m3101_ddl_scu.c g32m3101_ddl_spi.c g32m3101_ddl_usart.c g32m3101_ddl_utils.c
