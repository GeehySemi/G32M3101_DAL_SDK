# Keil uVision project IAP_Bootloader.uvprojx, settings and files
target G32M3101 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: G32M3101K8 Geehy
  pack: Geehy.G32M3101_DFP.1.0.4
  cpu: IRAM(0x20000000,0x00002000) IROM(0x00000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: IAP_Bootloader
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=3 wLevel=2
  c define: USE_FULL_DDL_DRIVER, G32M3101xx,BOARD_G32M3101_EVAL
  c include: ..\..\Include;..\..\..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\..\..\Libraries\G32M3101_DAL_Driver\Include;..\..\..\..\..\..\Libraries\Device\Geehy\G32M3101\Include;..\..\..\..\..\..\Boards\Board_G32M3101_Eval\Include;..\..\Config\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group CMSIS
    ./: startup_g32m3101xx.s
    ../../Source/: system_g32m3101.c
  group G32M3101_DDL_Driver
    ../../../../../../Libraries/G32M3101_DAL_Driver/Source/: g32m3101_ddl_adc.c g32m3101_ddl_atmr.c g32m3101_ddl_btmr.c g32m3101_ddl_comp.c g32m3101_ddl_crc.c g32m3101_ddl_div.c g32m3101_ddl_dma.c g32m3101_ddl_eint.c g32m3101_ddl_flash.c g32m3101_ddl_gpio.c g32m3101_ddl_gtmr.c g32m3101_ddl_lptmr.c g32m3101_ddl_spi.c g32m3101_ddl_scu.c g32m3101_ddl_usart.c g32m3101_ddl_utils.c
  group Board
    ../../../../../../Boards/Board_G32M3101_Eval/Source/: board_g32m3101_eval_ddl.c
  group Config
    ../../Config/Source/: g32m3101_device_cfg.c g32m3101_usart_cfg.c
  group Application
    ../../Source/: main.c g32m3101_int.c iap_common.c iap_flash.c iap_menu.c iap_ymodem.c
  group Document
    ../../: readme.txt
